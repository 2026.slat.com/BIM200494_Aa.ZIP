Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView]
File name: Z:/datBIM/02_Affaire/01_Clients/SLAT/TECHNIQUE/Catalogue_03_2020_RAJOUT/ifc_donnees/SDC-POE 5F DIN4 8P2F.ifc
Time: 2020-07-20T08:03:47
Written by: 3.0.2.347
Made in: Windows

# IfcProject, 0001
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 48, 52, 0, 117187; RefLongitude: 2, 19, 59, 880409; RefElevation: 0 mm
Autre - Catégorie: Informations sur le projet; Date de fin du projet: Date de fin; Adresse du projet: Entrer l'adresse ici; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: 0001; Etat du projet: Etat du projet

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du projet: Nom du projet; Numéro de projet: 0001; Catégorie: Informations sur le projet; Adresse du projet: Entrer l'adresse ici; Nom du client: Propriétaire

# IfcBuildingStorey: Niveau:Pointe 8 mm, Niveau 1
LongName: Niveau 1; Elevation: 0 mm
Autre - ID du type: Niveau: Pointe 8 mm; Famille et type: Niveau: Pointe 8 mm; Famille: Niveau: Pointe 8 mm; Catégorie: Niveaux; Type: Niveau: Pointe 8 mm
Contraintes - Elévation: 0 mm
Cotes - Hauteur de calcul: 0 mm
Données d'identification - Nom: Niveau 1; Structure: no; Etage de bâtiment: yes
Autre(Type) - Nom de la famille: Niveau; Catégorie: Niveaux
Contraintes(Type) - Base de l'élévation: Point de base du projet
Données d'identification(Type) - Nom du type: Pointe 8 mm
Graphismes(Type) - Symbole: Marqueur de niveau - Cercle: Marqueur de niveau - Cercle; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes; Epaisseur des lignes: 1; Couleur: 0; Motif des lignes: Centre

# IfcBuildingElementProxy: SDC-POE 5F DIN4 8P2F_slat, SLAT-:SDC-POE 5F DIN4 8P2F_slat:150553
In: Niveau 1
Type - Material: RSen_x_rgb 055 053 053 T00 gray_gen, RSen_x_rgb 255 255 255 T00 pure white_gen
Type - Pset_BuildingElementProxyCommon - Reference: SDC-POE 5F DIN4 8P2F_slat
Type - Pset_QuantityTakeOff - Reference: SDC-POE 5F DIN4 8P2F_slat
Type - Contraintes - Elévation par défaut: 1219.2 mm
Type - Electricité - TBQ Ficticious number of fase conductors: 1; TBQ Max allowed current: 3.2 A
Type - Données d'identification - Fabricant: SLAT; Modèle: SDC-POE 5F DIN4 8P2F; Nom du type: SDC-POE 5F DIN4 8P2F_slat
Type - Autre - Catégorie: Equipement électrique; datBIM.Largeur hors tout (overall width) (mm): 137.6 mm; datBIM.Libellé entité: SDC-POE 5F DIN4 8P2F; datBIM.Point de fixation (Mounting point): 1 ou 4; datBIM.Code datBIM entité: 83952145; datBIM.Produit repartis dans plusieurs enveloppes (Product divided into several envelopes): Non / No; datBIM.Qualification d'installateur : NF S 61-932 - Règles d'installation (Installer qualification : NF S 61-932 - Installation rules): Recommandé / Recommanded; datBIM.Marque commerciale (Commercial brand): SLAT; datBIM.Qualification du mainteneur (Qualification of the maintainer) : NF S 61-932 - Regles d¢installation NF S 61-970 - Regles d'installation des systemes de detection incendie - R7_NF S 61-932 (Installation rules NF S 61-970 - Installation rules for R7 fire: Recommandé / Recommanded; datBIM.Mode de communication (Communication mode): 8 Ports Ethernet 10/100/1000 Mbps + 2 Port SFP 100/1000 Mbps /8 Ethernet ports 10/100/1000 Mbps + 2 SFP ports 100/1000 Mbps; datBIM.Conformite ATEX (ATEX compliance): Non / No; datBIM.Hauteur hors tout ( overall height) (mm): 148 mm; datBIM.Profondeur hors tout (overall depth) (mm): 215 mm; datBIM.Qualification du mainteneur (Qualification of the maintainer : Annexe B NF S 61-933 - SDI Annexe J NF S 61-933 Alimentation Annexe L NF S 61-933 Exploitant_Appendix B NF S 61-933 - SDI Appendix J NF S 61-933 Power supply Appendix L NF S 61-933 Operator): Recommandé / Recommanded; datBIM.Qualification du mainteneur : Annexe J NF S 61-933 Alimentation (Qualification of the maintainer : Appendix J NF S 61-933 Power supply): Recommandé / Recommanded; datBIM.Qualification du mainteneur : Annexe L NF S 61-933 Exploitant (Qualification of the maintainer : Appendix L NF S 61-933 Operator): Recommandé / Recommanded; datBIM.Fonction generique (Generic function): Switch secourue / Emergency switch; datBIM.Profondeur (Depth) (mm): 215 mm; datBIM.Qualification d'installateur : NF S 61-970 - Règles d'installation des systèmes de détection incendie (Installer qualification : Installation rules for fire detection systems): Recommandé / Recommanded; datBIM.Rendement energetique (Energy efficiency): 0.76; datBIM.Temperature d'utilisation (Operating temperature): -10 à +45 °C; datBIM.Qualification d'installateur : R7 (Installer qualification : R7): Recommandé / Recommanded; datBIM.Substance visee par REACH_DEEE (Substance covered by REACH_WEEE): Non / No; datBIM.Site WEB du fournisseur: Https://www.slat.com; datBIM.Classe electrique (Electrical class): 1; datBIM.Tension de fonctionnement [Min-Max] (Mains voltage [Min-Max]): 195.5 à 264.5 V; datBIM.Poids (Weight): 2.2; datBIM.Type de liaison (Type of link): Filaire / Wired; datBIM.Type d'installation (Mounting type): Mural - Rail DIN (Wall-mounted and DIN rail-mounted); datBIM.Qualification du mainteneur : Annexe B NF S 61-933 - SDI (Qualification of the maintainer : Appendix B NF S 61-933 - SDI): Recommandé / Recommanded; datBIM.Tension nominale de sortie (Rated output voltage): 55 V; datBIM.Nombre de sorties d'alimentation (Number of power supply outputs): 8; datBIM.Consommation electrique (Primary current): 1.7 A; datBIM.Duree de la garantie (warranty period): 3 ans / years; datBIM.Duree de vie previsionnelle de reconditionnement (Expected life of refurbishment): 10 ans / years; datBIM.Matiere de l'enveloppe (Envelope material): Aluminium; datBIM.Id: datBIM:1510136687458; datBIM.Largeur (Width) (mm): 137.6 mm; datBIM.Duree de vie previsionnelle (Expected life expectancy): 10 ans / years; datBIM.Puissance (Output power): 180 W; datBIM.Couleur dominante (Dominant color): Blanc / White; datBIM.Courant maximal d'utilisation (Maximal output current): 3.2 A; datBIM.Description longue entité: <p><em>Ref. : </em><i>83952145</i></p><p><i>SDC-PoE8 est un Switch PoE/PoE+ manageable layer 2+, 8 Ports avec fonction Micro-UPS DC intégré (batterie LiFePO4). Avec 8 ports en full-Gigabit dont 2 SFP pour les liaisons fibres, le switch raccorde et alimente les équipements connectés, tels que les caméras, enregistreurs, centrales d?alarme, etc? Il gère leurs flux de données et surveille le bon fonctionnement des équipements.</i></p><p><i>En cas de coupure de courant, il assure la continuité de service, et le maintien opérationnel des équipements alimentés en PoE/PoE+/PoE++ (High PoE)</i></p><p><i>SDC-PoE8 is a manageable layer 2+, 8-port PoE/PoE+ switch with integrated DC Micro-UPS function (LiFePO4 battery). With 8 full-Gigabit ports, including 2 SFP ports for fiber connections, the switch connects and powers connected equipment, such as cameras, recorders, alarm systems, etc. It manages their data flows and monitors the proper functioning of the equipment.</i><br></p><p><i>In the event of a power failure, it ensures the continuity of service and the operational maintenance of equipment powered by PoE/PoE+/PoE++ (High PoE)</i></p><p><i></i><br></p>; datBIM.Degre d'etancheite IP (Protection class IP): IP20; datBIM.Hauteur (Height) (mm): 121.8 mm; Nom de la famille: SLAT-
Type - Matériaux et finitions - TBQ Material 01: RSen_x_rgb 255 255 255 T00 pure white_gen; TBQ Material 02: RSen_x_rgb 055 053 053 T00 gray_gen
Type - Cotes - TBQ Length: 215 mm; TBQ Height: 137.6 mm; TBQ Width: 124 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: SLAT
Pset_BuildingElementProxyCommon - sets with these values: 2
Autre - Famille: SLAT-: SDC-POE 5F DIN4 8P2F_slat; Famille et type: SLAT-: SDC-POE 5F DIN4 8P2F_slat; Type: SLAT-: SDC-POE 5F DIN4 8P2F_slat; ID du type: SLAT-: SDC-POE 5F DIN4 8P2F_slat
Contraintes - Hôte: Niveau : Niveau 1; Niveau: Niveau: Niveau 1; Élévation par rapport au niveau: 0 mm; Niveau de nomenclature: Niveau: Niveau 1
Cotes - Surface: 0.119 m2; Volume: 0.004 m3
Données d'identification - Identifiant: 1
Electricité - TBQ Power_factor: 1; TBQ Number_of_poles: 1; TBQ Voltage: 230 V
Electricité - Charges - Facteur de charge totale: 1; Charge apparente des bornes de passage Phase A: 0 W; Charge apparente - Phase A: 0 W; Charge apparente - Phase B: 0 W; Charge apparente - Phase C: 0 W; Charge apparente des bornes de passage Phase C: 0 W; Charge apparente des bornes de passage Phase B: 0 W; Charge apparente du circuit de dérivation Phase A: 0 W; Charge apparente du circuit de dérivation Phase B: 0 W; Charge apparente du circuit de dérivation Phase C: 0 W; Charge totale connectée: 0 W; Demande de charge totale estimée: 0 W
Electricité - Circuit - Cosses d'artère secondaire: yes; Intensité nominale MCB: 1 A; Données électriques: 230 V/1-0 VA; Option de numérotation de circuit: Par défaut; Bornes de passage: yes
Phase de construction - Phase de création: Phase 1
eveBIM PSet - Visibility: yes

# IfcDistributionPort, Port_150553
Description: Flow; FlowDirection: SOURCEANDSINK
